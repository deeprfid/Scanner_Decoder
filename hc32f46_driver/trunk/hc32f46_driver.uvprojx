# Keil uVision project hc32f46_driver.uvprojx, settings and files
target bspdrv (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.10
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f46_driver (library)
  AfterMake: xcopy .\output\hc32f46_driver.lib  ..\..\driver_lib /Y
  AfterMake: xcopy .\hc32f46_driver.h  ..\..\driver_lib /Y
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: USE_DEVICE_DRIVER_LIB,HC32F460,BSP_EV_HC32F460_LQFP100_V2
  c misc: --diag_suppress=186,66
  c include: .\DHCP;.\DNS;.\FTPClient;.\FWlib\inc;.\user\inc;.\wizchip\W5100S;.\wizchip;.\rtos2_help;.\;.\usb_lib\device_class\custom_hid;.\usb_lib\device_class\hid_cdc_composite;.\usb_lib\device_class\single_cdc;.\usb_lib\device_core;.\usb_lib\examp;.\usb_lib\usb_core;.\usb_lib\device_class\hid_keyboard;..\..\driver_lib
  asm define: STARTUP_CODE_SUPPORT
  memory RVCT4: ROM 0x10000 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group user
    ./user/src/: common.c irq.c pio.c timer.c uart.c readercfg.c io_stream.c os_dep.c main.c usb_utility.c custom_ee_commond.c flash_op.c usr_mod.c wiegand.c trng.c license.c
    ./: hc32f46_driver.h
    ./user/inc/: driverconfig.h readercfg.h io_stream.h
  group FWLib
    ./FWlib/src/: hc32f460_clk.c hc32f460_gpio.c hc32f460_interrupts.c hc32f460_pwc.c hc32f460_usart.c hc32f460_timera.c hc32f460_utility.c hc32f460_sram.c hc32f460_swdt.c hc32f460_spi.c hc32f460_icg.c hc32f460_dmac.c hc32f460_adc.c hc32f460_trng.c hc32f460_hash.c hc32f460_wdt.c hc32f460_sdioc.c hc32f460_qspi.c hc32f460_keyscan.c hc32f460_crc.c hc32f460_aes.c hc32f460_event_port.c hc32f460_i2c.c hc32f460_timer0.c hc32f460_timer4_pwm.c hc32f460_timer6.c
  group wizchip
    ./wizchip/: socket.c wizchip_conf.c port.c
    ./wizchip/W5100S/: w5100s.c
  group rtos2_help
    ./rtos2_help/: rtx_lib.c RTX_Config.h RTX_Config.c
  group DHCP
    ./DHCP/: dhcp.c
  group DNS
    ./DNS/: dns.c
  group FTPClient
    ./FTPClient/: ftpc.c
  group usb_lib
    ./usb_lib/device_class/custom_hid/: usb_dev_custom_hid_class.c
    ./usb_lib/device_class/hid_cdc_composite/: usb_dev_hid_cdc_wrapper.c
    ./usb_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
    ./usb_lib/examp/: usb_dev_desc.c usb_dev_user.c usb_bsp.c
    ./usb_lib/usb_core/: usb_core_driver.c
    ./usb_lib/device_class/hid_keyboard/: usb_dev_keyboard_class.c
    ./usb_lib/device_class/single_cdc/: usb_dev_cdc_class.c
  group SNTP
    ./SNTP/: sntp.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0
