# Keil uVision project firmware_t.uvprojx, settings and files
target firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.10
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__SCM__,HC32F460,_RTE_
  c misc: --diag_suppress=186,66
  c include: ..\..\driver_lib;.\user\src;.\MQTT\MQTTPacket\src;.\MQTT;.\user\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Firmware.sct
  link misc: --keep=*Handler
  group user
    ./user/src/: ErrChecker.c customcmd.c Lan2Uart.c user_main.c static_conf.c modbus_mode.c http_callback.c reader_msg.c reader_init.c event_mq.c ipc.c ota_frame.c ota_security.c ota_state.c ota_storage.c ota_http.c ota_agent.c ota_server.c
  group CM4
    ./CM4/: startup_hc32f46x.s system_hc32f460.c
  group MQTT
    ./MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeServer.c
    ./MQTT/: mqtt_interface.c MQTTClient.c
  group httpapi
    ./httpapi/: APIHttpRequest.cpp APIHttpResponse.cpp httpAPI.cpp HttpModuleAPI.cpp TAGINFOBuffer.cpp Utility.cpp
  group Jsonlib
    ./jsonlib/: http_parser.c json-parser.c mp_pool.c TagBuffer.c
    ./user/src/: w25qxx.c
  group applib
    ../../driver_lib/: RTX_CM4F.lib hc32f46_driver.lib ModuleAPI_C_ARM.lib
software components: CMSIS:CORE 5.4.0, Security:mbed TLS 2.28.0
