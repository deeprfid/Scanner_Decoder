# Keil uVision project HC32F460JEUABootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.10
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,HC32F460
  c misc: --diag_suppress=186,66
  c include: ..\..\driver_lib;.\user\inc;.\CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Bootloader.sct
  link misc: --keep=*Handler
  group CM4
    ./CM4/: startup_hc32f460.s system_hc32f460.c
  group user
    ./user/src/: main.c fw_jump_helper.c btMsg.c update_by_ftp.c
    ./user/inc/: fw_jump_helper.h app_conf.h update_by_ftp.h
    ../../driver_lib/: hc32f46_driver.lib
software components: CMSIS:CORE 5.4.0
